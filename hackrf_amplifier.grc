options:
  parameters:
    generate_options: qt_gui
    id: hackrf_amplifier
    output_language: python
    title: HackRF Amplifier Control
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 100e6
    step: '1'
    stop: 110e6
    value: 107e6
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: '47'
    value: '20'
  states: {}
- name: rf_gain
  id: variable_qtgui_check_box
  parameters:
    'false': '1'
    'true': '14'
    type: int
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: complex
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '20'
    freq0: freq
    gain0: rf_gain
    if_gain0: if_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_const_source_x_0, '0', osmosdr_sink_0, '0']

metadata:
  file_format: 1
